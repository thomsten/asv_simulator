Commit message: Minor config changes.

File: config/models/revolt.urdf (robot description, URDF)
Before this commit: robot asv, 1 links, 0 joints
Links:
- link asv: geometry visual mesh filename=package://asv_simulator/meshes/viksund.STL scale=0.001 0.001 0.001
