Commit message: Added a mesh for the ReVolt vessel

File: config/models/simple.urdf (robot description, URDF)
Before this commit: robot asv, 1 links, 0 joints
Links:
- link asv: geometry visual mesh filename=package://asv_simulator/meshes/Revolt.STL scale=0.001 0.001 0.001
